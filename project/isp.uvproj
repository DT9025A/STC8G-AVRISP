# Keil uVision project isp.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: isp +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
  group Program
    ./: STARTUP.A51
    ../src/: main.c
  group System
    ../src/: delay.c spi.c uart.c
  group STK500
    ../src/: stk500.c
